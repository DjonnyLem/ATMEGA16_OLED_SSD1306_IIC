<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>R:\MK_proj\avr_proj\IAR\DS1307-iar-2\ds1307-iar.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ds1307-iar-3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


